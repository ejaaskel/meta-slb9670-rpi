SRC_URI += "file://fragment.cfg;subdir=git \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

